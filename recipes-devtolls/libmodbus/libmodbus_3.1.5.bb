include libmodbus.inc

SRCREV="890e689b9e6a806e26d7072e142cf2b3bda62755"
