
include libmodbus.inc

SRCREV="f9358460ee1f62bcac716ad0444b3bbe7628b204"

