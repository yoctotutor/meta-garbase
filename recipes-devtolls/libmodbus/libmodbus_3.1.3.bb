

include libmodbus.inc

SRCREV="81cc4a7e5389405c35d4ebc8173b07654160e834"

